# Keil uVision project STM32F407.uvproj, settings and files
target DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ..\STM407 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: ..\CORE;..\User;..\Libraries\inc;..\FSC_STOS;..\User\Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: main.c
    ../CORE/: stm32f4xx_it.c
  group Driver
    ../User/Driver/: usart.c usart.h
  group STM32core
    ../CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group STM32F4_lib
    ../Libraries/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group FSC_STOS
    ../FSC_STOS/: APP.c FSC_STOS.asm FSC_STOS.c FSC_STOS.h
  group Txt
    ../TXT/: Readme.txt
