# Keil uVision project FSC_STOS_STM32F0xx.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FSC_STOS_STM32F0xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\STM32F0\CORE;.\STM32F0\STM32F03x_FWLib\inc;.\User;.\STM32F0;.\FSC_STOS;.\User\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./User/: main.c
  group Driver
    ./User/Driver/: led.c led.h USART1.c USART1.h
  group STM32
    ./STM32F0/CORE/: startup_stm32f0xx.s
    ./STM32F0/: system_stm32f0xx.c
    ./STM32F0/STM32F03x_FWLib/src/: stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c
  group FSC_STOS
    ./FSC_STOS/: APP.c FSC_STOS.asm FSC_STOS.c FSC_STOS.h
