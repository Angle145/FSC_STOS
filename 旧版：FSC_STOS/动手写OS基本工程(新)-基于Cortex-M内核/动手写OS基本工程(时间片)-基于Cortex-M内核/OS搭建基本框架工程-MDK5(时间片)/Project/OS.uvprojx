# Keil uVision project OS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Cortex-M3-STM32F1\CMSIS;..\Cortex-M3-STM32F1\STM32F10x_StdPeriph_Driver\inc;..\Cortex-M3-STM32F1;..\OS;..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../: main.c
  group User
    ../User/: usart.c usart.h
  group Cortex-M3
    ../Cortex-M3-STM32F1/STM32F10x_StartFile/: startup_stm32f10x_hd.s
    ../Cortex-M3-STM32F1/CMSIS/: core_cm3.c
    ../Cortex-M3-STM32F1/: system_stm32f10x.c
    ../Cortex-M3-STM32F1/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group OS
    ../OS/: OS.asm OS.c OS.h
