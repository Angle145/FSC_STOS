# Keil uVision project FSC_STOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FSC_STOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\FSC_STOS;.\Stm32f1_File\CMSIS\STM32F10x_StartFile;.\Stm32f1_File\CMSIS;.\Stm32f1_File\STM32F10x_StdPeriph_Driver\inc;.\User\Driver;.\User;.\Stm32f1_File
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c STM32F10x_C51Mode.h STM32F10xPeripMode.h
  group Driver
    ./User/Driver/: ds18b20.c ds18b20.h ds3231.c ds3231.h i2c_gpio.c i2c_gpio.h eeprom_24xx.c eeprom_24xx.h
  group Fsc_stos
    ./FSC_STOS/: FSC_STOS.h FSC_STOS.c FSC_STOS.asm APP.c
  group Stm32f1-File
    ./Stm32f1_File/CMSIS/STM32F10x_StartFile/: startup_stm32f10x_hd.s
    ./Stm32f1_File/CMSIS/: core_cm3.c
    ./Stm32f1_File/: system_stm32f10x.c
    ./Stm32f1_File/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_wwdg.c
  group Txt
    ./TXT/: Readme.txt
