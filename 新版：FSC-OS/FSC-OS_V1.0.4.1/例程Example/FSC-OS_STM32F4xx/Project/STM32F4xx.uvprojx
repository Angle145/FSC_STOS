# Keil uVision project STM32F4xx.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: ..\STM32\CMSIS\Device\ST\STM32F4xx\Include;..\STM32\CMSIS\Include;..\STM32\STM32F4xx_StdPeriph_Driver\inc;..\MY;..\Drive\Include;..\OS;..\App
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MY
    ../MY/: main.c stm32f4xx_it.c
  group Drive
    ../Drive/Source/: led.c usart.c
    ../Drive/Include/: led.h usart.h
  group STM32
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group FSC-OS
    ../OS/: Conf.h Global.c Global.h List.c List.h Mem.c Mem.h Method.c Method.h OS.asm OS.c OS.h OS_main.c Shell.c Shell.h Signal.c Signal.h Type.c Type.h
  group APP_01
    ../App/: app_01.c app_01.h
