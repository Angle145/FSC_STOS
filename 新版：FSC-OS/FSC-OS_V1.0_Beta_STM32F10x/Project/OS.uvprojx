# Keil uVision project OS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Cortex-M3-STM32F1\CMSIS;..\Cortex-M3-STM32F1\STM32F10x_StdPeriph_Driver\inc;..\Cortex-M3-STM32F1;..\OS;..\User;..\..\OS搭建基本框架工程-MDK5(抢占式);..\User;..\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../: main.c
    ../User/: STM32F10x_C51Mode.h
  group App_01
    ../App/: app_01.c app_01.h
  group App_02
    ../App/: app_02.c app_02.h
  group User
    ../User/: usart.c usart.h
  group Cortex-M3
    ../Cortex-M3-STM32F1/STM32F10x_StartFile/: startup_stm32f10x_hd.s
    ../Cortex-M3-STM32F1/CMSIS/: core_cm3.c
    ../Cortex-M3-STM32F1/: system_stm32f10x.c
    ../Cortex-M3-STM32F1/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group OS
    ../OS/: Conf.h OS_main.c OS.asm OS.c OS.h Mem.c Mem.h List.c List.h Type.c Type.h Shell.c Shell.h Signal.c Signal.h Global.c Global.h Method.c Method.h
